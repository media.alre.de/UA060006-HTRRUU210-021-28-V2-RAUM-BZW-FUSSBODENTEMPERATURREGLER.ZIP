Properties of the parts of a building model (IFC4)

# File
Description: Raum-/Fußbodentemperaturregler mit Uhr, UP, Abdeckung passend zu BUSCH-JAEGER Reflex SI/SI Linear, reinweiß, glänzend, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UA060006, Raum-/Fußbodentemperaturregler mit Uhr, UP, Abdeckung passend zu BUSCH-JAEGER Reflex SI/SI Linear, reinweiß, glänzend
In: Raum
Description: Universeller Unterputz-Temperaturregler zur zeitabhängigen Einzelraum- oder Fußbodentemperaturregelung für Elektro- und Warmwasserheizungen (stromlos geschlossene Stellantriebe). Dabei kann das Gerät als Raumtemperaturregler (wahlweise auch mit optionalem externen Raumfühler), mit optionalem Fernfühler auch als Raumtemperaturregler mit Fußbodenüberwachung oder als Fußbodentemperaturregler eingesetzt werden. Dieser Uhrenthermostat besitzt eine Wochenuhr mit individuell einstellbaren Programmen (Werkseinstellung auf „normale“ Tagesabläufe). Einfachste Handhabung durch intuitive Bedienung, Kostenoptimierung durch zeitgesteuerte Regelung auf die gewünschten Temperaturen. Beleuchtetes, grafikfähiges Display. Komfortable Montage durch freie Verdrahtung der steckbaren Schraubklemmen.; Classification: EC011309 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UA060006; ModelLabel: HTRRUu210.021#28/V2; GlobalTradeItemNumber: 4050528058225; ProductURL: https://alre.de/produkt_UA060006
Pset_Specification - NominalLength: 0.071 m; NominalWidth: 0.071 m; NominalDepth: 0.046 m; NetWeight: 0.131
Pset_ALRE_ETIM_Properties - Farbe: weiß; Breite: 71; Höhe: 71; Tiefe: 46; RAL-Nummer: 9010; Art der Spannungsversorgung: 230 V; Kontaktausführung: Schließer (NO); Messbereich: 5; Bedienung: Taste; Explosionsgeschützt: no; Uhrentyp: Wochenuhr; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Klasse des Temperaturreglers: IV; Max. Spannung der Kontakte: 230; Regelcharakteristik: PI; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 0; Ausführung Uhr: digital; Überstundenschalter: yes; Temperatur ablesbar: yes; Optimierung: yes; Anzahl der Schaltprogramme: 7; Max. Kontaktbelastung: 10; Differenzwert: 0.5; Sensor extern: no; Differenz verstellbar: no; Geeignet für Heizung: yes; ETIM-Klasse: EC011309; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UA060006.pdf
